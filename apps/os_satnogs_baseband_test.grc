options:
  parameters:
    author: nickoe
    generate_options: qt_gui
    id: os_satnogs_baseband_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Squelch
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '-50'
    value: '-80'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: filter_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: os_samp_rate
  id: variable
  parameters:
    value: '57600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 10e3
    gain: '1'
    samp_rate: samp_rate
    width: '60000'
    win: firdes.WIN_HAMMING
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '25000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: xlate_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 25e3
    gain: '1'
    samp_rate: samp_rate
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (2*math.pi*deviation)/audio_samp_rate
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: blks2_rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.0'
    interp: '6'
    taps: taps
    type: ccc
  states: {}
- name: blks2_rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.0'
    interp: '6'
    taps: taps
    type: ccc
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Emulates Satnogs-like recording
    file: satnogs_baseband_48000sps
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/nickoe/gr-opssat/recordings/osat_437.16M_200k_beacon_mode6.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: lo_offset
    decim: int(samp_rate/filter_rate)
    samp_rate: samp_rate
    taps: xlate_filter_taps
    type: ccc
  states: {}
- name: lo_offset
  id: parameter
  parameters:
    comment: |-
      To avoid the SDR carrier at the DC
      we shift the LO a little further
    type: eng_float
    value: 40e3
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: os_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"satnogs rate"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: rx rate
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satnogs_ogg_encoder_0
  id: satnogs_ogg_encoder
  parameters:
    Quality: '0.8'
    filename: /home/nickoe/gr-opssat/recordings/osat_437.16M_250k_beacon_realistic_mode6_satnogs_fake.ogg
    samp_rate: audio_samp_rate
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', satnogs_ogg_encoder_0, '0']
- [analog_simple_squelch_cc_0, '0', zeromq_pub_sink_0, '0']
- [blks2_rational_resampler_xxx_1, '0', analog_quadrature_demod_cf_0, '0']
- [blks2_rational_resampler_xxx_1, '0', blks2_rational_resampler_xxx_1_0, '0']
- [blks2_rational_resampler_xxx_1, '0', blocks_file_sink_0, '0']
- [blks2_rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blks2_rational_resampler_xxx_1_0, '0', analog_simple_squelch_cc_0, '0']
- [blks2_rational_resampler_xxx_1_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blks2_rational_resampler_xxx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
