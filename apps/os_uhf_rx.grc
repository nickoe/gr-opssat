options:
  parameters:
    author: Fischer Benjamin, Mladenov Tom
    description: UHF RX application for offset sampling and doppler compensation (GPredict)
    generate_options: qt_gui
    id: os_uhf_rx
    output_language: python
    title: OPS-SAT UHF RX
  states: {}

blocks:
- name: Squelch
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '-50'
    value: '-130'
  states: {}
- name: doppler_freq
  id: variable
  parameters:
    value: true_freq - signal_freq
  states: {}
- name: freq_tuned
  id: variable
  parameters:
    value: offset_freq - doppler_freq
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: '-40e3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3*8
  states: {}
- name: samp_rate_down
  id: variable
  parameters:
    value: 57.6e3
  states: {}
- name: signal_freq
  id: variable
  parameters:
    value: 437.2e6
  states: {}
- name: true_freq
  id: variable
  parameters:
    value: signal_freq
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '25000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-freq_tuned'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/nickoe/gr-opssat/recordings/osat_437.16M_250ksps_mode6_realistic_beacon.cf32
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '1234'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_tuned'
    decim: '8'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: Determined by Gpredict
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Calculated
  states: {}
- name: note_1
  id: note
  parameters:
    note: Satellite frequency
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Offset sampling
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '625'
    interp: '144'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: signal_freq + offset_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: satnogs_coarse_doppler_correction_cc_0
  id: satnogs_coarse_doppler_correction_cc
  parameters:
    sampling_rate: samp_rate
    target_freq: true_freq
  states: {}
- name: satnogs_tcp_rigctl_msg_source_0
  id: satnogs_tcp_rigctl_msg_source
  parameters:
    addr: 127.0.0.1
    interval: '1000'
    mode: 'False'
    mtu: '1500'
    port: '4532'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: signal_freq + offset_freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', zeromq_pub_sink_0, '0']
- [rtlsdr_source_0, '0', satnogs_coarse_doppler_correction_cc_0, '0']
- [satnogs_coarse_doppler_correction_cc_0, '0', analog_simple_squelch_cc_0, '0']
- [satnogs_tcp_rigctl_msg_source_0, freq, blocks_message_debug_0, print]
- [satnogs_tcp_rigctl_msg_source_0, freq, satnogs_coarse_doppler_correction_cc_0, freq]

metadata:
  file_format: 1
